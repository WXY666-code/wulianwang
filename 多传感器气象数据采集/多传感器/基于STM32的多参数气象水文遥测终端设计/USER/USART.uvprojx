# Keil uVision project USART.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\RS485;..\HARDWARE\TIMER;..\HARDWARE\MODBUS;..\HARDWARE\OLED;..\SYSTEM\MyRTC;..\Library;..\HARDWARE\CountSensor;..\HARDWARE\Serial;..\USER;..\HARDWARE\BC26;..\HARDWARE\LED;..\HARDWARE\WDG;..\HARDWARE\SD;..\HARDWARE\MSD;..\MALLOC;..\HARDWARE\SPI;..\FATFS\exfuns;..\FATFS\src;..\HARDWARE\data;..\HARDWARE\TIMER;..\HARDWARE\HCSR04;..\HARDWARE\usart3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c stm32f10x_conf.h
  group HARDWARE
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/MODBUS/: modbus.c modbus_crc.c modbus_timer.c
    ../HARDWARE/OLED/: OLED.c
    ../HARDWARE/CountSensor/: CountSensor.c
    ../HARDWARE/BC26/: BC26.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SD/: sd.c
    ../HARDWARE/MSD/: MMC_SD.C
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/data/: data.c
    ../HARDWARE/TIMER/: Timer.c
    ../HARDWARE/Serial/: Serial.c
    ./: Kalman.c
    ../HARDWARE/usart3/: usart3.h usart3.c
    ../HARDWARE/HCSR04/: HCSR04.c HCSR04.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/MyRTC/: MyRTC.c MyRTC.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group Library
    ../Library/: misc.c misc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group FATFS
    ../FATFS/exfuns/: exfuns.c
    ../FATFS/src/: diskio.c ff.c
  group MALLOC
    ../MALLOC/: malloc.c
